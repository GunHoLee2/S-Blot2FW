<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\K-Blot_Light.ewp</path>
    </project>
    <batchBuild />
</workspace>
