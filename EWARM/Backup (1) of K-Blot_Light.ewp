# IAR project Backup (1) of K-Blot_Light.ewp, settings and files
configuration K-Blot_Light (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xE; USE_STM3210E_EVAL
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ../Drivers\Component; ../Drivers\Porject_Device; ../Drivers\MCU_Config; ../Drivers\CommonUtil; ../HS_Module; ../Drivers\BSP\STM3210E_EVAL
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sbt2_easy+_v002.bin
  ILINK.IlinkOutputFile: K-Blot_Light.out
  ILINK.IlinkIcfFile: stm32f103xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: adc.c cntrl.c eeprom.c error.c event.c k_blot_pr.c main.c motor.c pp_cal.c pump.c sq.c stm32f1xx_hal_msp.c stm32f1xx_it.c timer.c
  group Drivers
    ../Src/: usb_uart.c
  group Drivers/BSP_MCU_Config
    ../Drivers/MCU_Config/: hsBSP_MCU_Config.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Drivers/CommonUtill
    ../Drivers/CommonUtil/: hs_Common_Utill.c hs_CRC16.c hs_Que.c
  group Drivers/CommonUtill/Component
    ../Drivers/Component/: 17HS3410_Dspin.c hsAT24_EEPROM.c hsDRV88xx_StepmotorDrive.c hsTB6617_PeristalticPumpDrive.c
  group Drivers/CommonUtill/Component/Project_Device
    ../Drivers/Porject_Device/: KLight_Project_OnOff_Drive.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
